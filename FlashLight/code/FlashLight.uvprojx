# Keil uVision project FlashLight.uvprojx, settings and files
target FlashLight (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F303RG GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.1.0
  cpu: IRAM(0x20000000,0x018000) IROM(0x08000000,0x0100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: FlashLight +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_XD
  c include: ..\GD32F30x_Firmware_Library_V2.1.3\Firmware\CMSIS;..\GD32F30x_Firmware_Library_V2.1.3\Firmware\CMSIS\GD\GD32F30x\Include;..\GD32F30x_Firmware_Library_V2.1.3\Firmware\GD32F30x_standard_peripheral\Include;.\Application;..\GD32F30x_Firmware_Library_V2.1.3\Utilities
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group APPLICATION
    ./Application/: gd32f30x_it.c main.c systick.c board_gd32f303rgt6.c ztask_schedule.c
    ../GD32F30x_Firmware_Library_V2.1.3/Utilities/: gd32f307c_eval.c
  group CMSIS
    ../GD32F30x_Firmware_Library_V2.1.3/Firmware/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
    ../GD32F30x_Firmware_Library_V2.1.3/Firmware/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_xd.s
  group DRIVER
    ../GD32F30x_Firmware_Library_V2.1.3/Firmware/GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
